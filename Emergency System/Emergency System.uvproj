# Keil uVision project Emergency System.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Emergency System +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 emergency_system.c lcd.c lcd.h SIM808.c SIM808.h serial.c serial.h interrupt.c interrupt.h
